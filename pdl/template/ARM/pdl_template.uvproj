# Keil uVision project pdl_template.uvproj, settings and files
target Release (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: fm_pdl
  c flags: Optim=1
  c include: ..\..\common;..\..\template\source;..\..\driver;..\..\utility
  asm define: __CORE_FM3__
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group common
    ../../common/: system_fm0p.c system_fm3.c system_fm4.c
  group source_files
    ../source/: main.c
    ./: startup_fm.s retarget.c
  group driver
    ../../driver/: interrupts_fm0p.c interrupts_fm3.c interrupts_fm4.c pdl.c
    ../../driver/adc/: adc.c
    ../../driver/bt/: bt.c
    ../../driver/clk/: clk.c
    ../../driver/cr/: cr.c
    ../../driver/crc/: crc.c
    ../../driver/csv/: csv.c
    ../../driver/dac/: dac.c
    ../../driver/dma/: dma.c
    ../../driver/exint/: exint.c
    ../../driver/mfs/: mfs.c
    ../../driver/mft/: mft_frt.c mft_icu.c mft_adcmp.c mft_ocu.c mft_wfg.c
    ../../driver/dt/: dt.c
    ../../driver/lvd/: lvd.c
    ../../driver/ppg/: ppg.c
    ../../driver/qprc/: qprc.c
    ../../driver/uid/: uid.c
    ../../driver/wc/: wc.c
    ../../driver/wdg/: hwwdg.c swwdg.c
    ../../driver/rtc/: rtc.c
    ../../driver/lpm/: lpm.c
    ../../driver/vbat/: vbat.c
    ../../driver/i2sl/: i2sl.c
    ../../driver/reset/: reset.c
    ../../driver/dstc/: dstc.c
    ../../driver/extif/: extif.c
    ../../driver/flash/: dualflash.c mainflash.c workflash.c
    ../../driver/hbif/: hbif.c
    ../../driver/i2s/: i2s.c
    ../../driver/lcd/: lcd.c
    ../../driver/pcrc/: pcrc.c
    ../../driver/can/: can.c can_pre.c canfd.c
    ../../driver/hsspi/: hsspi.c
    ../../driver/rc/: rc.c
    ../../driver/icc/: icc.c
    ../../driver/sdif/: sdif.c
    ../../driver/i2cs/: i2cs.c
  group utility
    ../../utility/eeprom/: i2c_int_at24cxx.c i2c_polling_at24cxx.c
    ../../utility/hyper_flash/: s26kl512s.c
    ../../utility/i2s_codec/: wm8731.c
    ../../utility/nand_flash/: s34ml01g.c
    ../../utility/psram/: sv6p1615.c
    ../../utility/sdram/: is42s16800.c
    ../../utility/seg_lcd/cl010/: cl010.c
    ../../utility/seg_lcd/tsdh1188/: tsdh1188.c
    ../../utility/qspi_flash/: flashS25FL164K.c
    ../../utility/sd_card/: sd_card.c sd_cmd.c
    ../../utility/printf_scanf/: uart_io.c
target Debug (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: s6e1xx_pdl
  c flags: Optim=1
  c include: as above
  asm define: __CORE_FM3__
  library: MicroLIB
  memory RVCT4: ROM 0x1fff8000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
