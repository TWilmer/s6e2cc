# IAR project pdl_template.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: MB9BF506R Fujitsu MB9BF506R
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\common; ..\..\template\source; ..\..\driver; ..\..\utility
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: pdl_template.srec
  ILINK.IlinkOutputFile: mb9bfxxx_pdl.out
  ILINK.IlinkIcfFile: config\mb9bf50x\mb9bf506.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration debug (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  OBJCOPY.OOCOutputFile: mb9bfxxx_pdl.srec
  group (top)
    ../../: Readme.txt
  group common
    ../../common/: system_fm0p.c system_fm3.c system_fm4.c
  group driver
    ../../driver/adc/: adc.c
    ../../driver/bt/: bt.c
    ../../driver/can/: can.c can_pre.c canfd.c
    ../../driver/clk/: clk.c
    ../../driver/cr/: cr.c
    ../../driver/crc/: crc.c
    ../../driver/csv/: csv.c
    ../../driver/dac/: dac.c
    ../../driver/dma/: dma.c
    ../../driver/dstc/: dstc.c
    ../../driver/dt/: dt.c
    ../../driver/flash/: dualflash.c mainflash.c workflash.c
    ../../driver/exint/: exint.c
    ../../driver/extif/: extif.c
    ../../driver/hbif/: hbif.c
    ../../driver/hsspi/: hsspi.c
    ../../driver/wdg/: hwwdg.c swwdg.c
    ../../driver/i2cs/: i2cs.c
    ../../driver/i2s/: i2s.c
    ../../driver/i2sl/: i2sl.c
    ../../driver/icc/: icc.c
    ../../driver/: interrupts_fm0p.c interrupts_fm3.c interrupts_fm4.c pdl.c
    ../../driver/lcd/: lcd.c
    ../../driver/lpm/: lpm.c
    ../../driver/lvd/: lvd.c
    ../../driver/mfs/: mfs.c
    ../../driver/mft/: mft_adcmp.c mft_frt.c mft_icu.c mft_ocu.c mft_wfg.c
    ../../driver/pcrc/: pcrc.c
    ../../driver/ppg/: ppg.c
    ../../driver/qprc/: qprc.c
    ../../driver/rc/: rc.c
    ../../driver/reset/: reset.c
    ../../driver/rtc/: rtc.c
    ../../driver/sdif/: sdif.c
    ../../driver/uid/: uid.c
    ../../driver/vbat/: vbat.c
    ../../driver/wc/: wc.c
  group source_files
    ../source/: main.c
    ./: startup_fm.s
  group utility
    ../../utility/seg_lcd/cl010/: cl010.c
    ../../utility/qspi_flash/: flashS25FL164K.c
    ../../utility/eeprom/: i2c_int_at24cxx.c i2c_polling_at24cxx.c
    ../../utility/sdram/: is42s16800.c
    ../../utility/hyper_flash/: s26kl512s.c
    ../../utility/nand_flash/: s34ml01g.c
    ../../utility/sd_card/: sd_card.c sd_cmd.c
    ../../utility/psram/: sv6p1615.c
    ../../utility/seg_lcd/tsdh1188/: tsdh1188.c
    ../../utility/printf_scanf/: uart_io.c
    ../../utility/i2s_codec/: wm8731.c
